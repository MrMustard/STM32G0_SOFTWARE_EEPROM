# IAR project Project.ewp, settings and files
configuration NUCLEO-C031C6 (ARM, debug)
  General.OGChipSelectEditMenu: STM32C031C6 ST STM32C031C6
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32C031xx
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\Drivers\STM32C0xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\STM32C0xx_HAL_Driver\Inc\Legacy; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32C0xx\Include; ..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\Drivers\BSP\STM32C0xx_Nucleo; ..\..\..\..\..\Middlewares\ST\EEPROM_Emul\Core; ..\..\..\..\..\Middlewares\ST\EEPROM_Emul\Porting\STM32C0
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: NUCLEO-C031C6.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32c031xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32c031xx.s
  group Application/User
    ../../Src/: main.c stm32c0xx_it.c
  group Doc
    ../../: readme.txt
  group Drivers/BSP/STM32C0xx_Nucleo
    ../../../../../Drivers/BSP/STM32C0xx_Nucleo/: stm32c0xx_nucleo.c
  group Drivers/CMSIS
    ../../Src/: system_stm32c0xx.c
  group Drivers/STM32C0xx_HAL_Driver
    ../../../../../Drivers/STM32C0xx_HAL_Driver/Src/: stm32c0xx_hal.c stm32c0xx_hal_cortex.c stm32c0xx_hal_flash.c stm32c0xx_hal_flash_ex.c stm32c0xx_hal_gpio.c stm32c0xx_hal_pwr.c stm32c0xx_hal_pwr_ex.c stm32c0xx_hal_rcc.c stm32c0xx_hal_rcc_ex.c
  group Middlewares/Core
    ../../../../../Middlewares/ST/EEPROM_Emul/Core/: eeprom_emul.c
  group Middlewares/Porting
    ../../../../../Middlewares/ST/EEPROM_Emul/Porting/STM32C0/: flash_interface.c
